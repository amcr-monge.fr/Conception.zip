page("TeklaStructures","")
{
   joint(1, "MANCHON")
   {
       tab_page("", " Paramètres 1 ", 1)
       {
           parameter("Préfixe Pièce", "P1", string, text, 1)
           parameter("Préfixe Assemblage", "P3", string, text, 2)
           parameter("N° début Pièce", "P2", integer, number, 3)
           parameter("N° début Assemblage", "P4", integer, number, 4)
           parameter("Classe", "P7", integer, number, 5)
       }
   }
}