page("TeklaStructures","")
{
   joint(1, "MANCHON DE CROISEMENT")
   {
       tab_page("", " Paramètres 1 ", 1)
       {
           parameter("Classe", "P16", integer, number, 1)
           parameter("N° début Assemblage", "P13", integer, number, 2)
           parameter("Préfixe Assemblage", "P12", string, text, 3)
           parameter("N° début Pièce", "P11", integer, number, 4)
           parameter("Préfixe Pièce", "P10", string, text, 5)
       }
   }
}