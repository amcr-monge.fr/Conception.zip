Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Tekla.ifc
Time: 2024-10-30T17:42:29
Author: DESKTOP-II8P2ID\franc
Organization: Structural Designer
Written by: IFC Parser Version: 3.13.2
Made in: Tekla Structures Educational 2023 Service Pack 4, IFC Export Version: 4.0.0.0 Jun 12 2023

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: IPE120 (8)
In: Undefined
Description: IPE120; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: no; Reference: 0(?)
Tekla Commun - Niveau bas: -0.428; Niveau haut: -0.308; Repère de pièce: 0(?); Repère d'assemblage: P0(?); Finition: BECHE; Phase: 1; Classe: 99; Matériau: S235JR; Profil: IPE120; Nom: BECHE
Tekla Quantités - Poids: 1.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 45.8 m2; Surface nette: 0.1 m2; Hauteur: 120 mm; Largeur: 64 mm; Longueur: 120 mm
BaseQuantities - Length: 120 mm; OuterSurfaceArea: 0.057 m2; NetVolume: 0.000153475 m3; NetWeight: 1.20478 kg

# IfcBeam: IPE160 (50)
In: Undefined
Description: IPE160; Material: STEEL/S275JR
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 2; Matériau: S275JR; Profil: IPE160; Nom: PANNE
Tekla Quantités - Poids: 78.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 39.5 m2; Surface nette: 3.2 m2; Hauteur: 160 mm; Largeur: 82 mm; Longueur: 5000 mm
BaseQuantities - Length: 5000 mm; OuterSurfaceArea: 3.115 m2; NetVolume: 0.009698 m3; NetWeight: 76.1293 kg
Name | Niveau bas | Niveau haut
10 x PANNE | +3.840 | +4.010
10 x PANNE | +4.138 | +4.308
10 x PANNE | +4.435 | +4.605
10 x PANNE | +3.543 | +3.713
10 x PANNE | +4.733 | +4.903

# IfcBeam: IPE200 (2)
In: Undefined
Description: IPE200; Material: STEEL/S275JR
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Niveau bas: +3.345; Niveau haut: +4.757; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 4; Matériau: S275JR; Profil: IPE200; Nom: RAMASSE
Tekla Quantités - Poids: 183.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 34.3 m2; Surface nette: 6.5 m2; Hauteur: 200 mm; Largeur: 100 mm; Longueur: 8188.5 mm
BaseQuantities - Length: 8188.51 mm; OuterSurfaceArea: 6.28878 m2; NetVolume: 0.0222712 m3; NetWeight: 174.829 kg

# IfcBeam: IPE270, TRAVERSE
In: Undefined
Description: IPE270; Material: STEEL/S275JR
Tekla Commun - Niveau bas: +3.250; Niveau haut: +3.520; Repère de pièce: 0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 6; Matériau: S275JR; Profil: IPE270; Nom: TRAVERSE
Tekla Quantités - Poids: 159.5 kg; Volume: 0 m3; Surface supérieure totale: 0.6 m2; Surface par tonne: 28.9 m2; Surface nette: 4.7 m2; Hauteur: 270 mm; Largeur: 135 mm; Longueur: 4428 mm
Pset_BeamCommon - LoadBearing: no; Reference: 0(?)
BaseQuantities - Length: 4428 mm; OuterSurfaceArea: 4.60955 m2; NetVolume: 0.0194892 m3; NetWeight: 152.99 kg

# IfcBeam: IPE330 (20)
In: Undefined
Description: IPE330
Pset_BeamCommon - LoadBearing: no; Reference: 0(?)
Tekla Commun - Repère de pièce: 0(?); Repère d'assemblage: A0(?); Phase: 1; Profil: IPE330
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 25.5 m2; Largeur: 160 mm
Name | Material | Niveau bas | Niveau haut | Classe | Matériau | Nom | Poids (kg) | Surface nette (m2) | Hauteur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
10 x JARRET | STEEL/S235JR | +2.915 | +3.494 | 99 | S235JR | JARRET | 89.4 | 1.1 | 318.5 | 1818.4 | 1818.41 | 2.28029 | 0.0101821 | 79.9292
10 x TRAVERSE | STEEL/S275JR | +3.253 | +4.755 | 4 | S275JR | TRAVERSE | 389.5 | 10.1 | 330 | 7926.7 | 7926.65 | 9.94002 | 0.047125 | 369.932

# IfcBeam: L60*6 (12)
In: Undefined
Description: L60*6; Material: STEEL/S275JR
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 6; Matériau: S275JR; Profil: L60*6; Nom: CV
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 43 m2; Surface nette: 1.5 m2; Hauteur: 60 mm; Largeur: 60 mm
Name | Niveau bas | Niveau haut | Poids (kg) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x CV | -0.324 | +3.572 | 34.2 | 6309.7 | 6309.72 | 1.47016 | 0.00431585 | 33.8794
4 x CV | +3.492 | +4.147 | 34.8 | 6409.8 | 6409.85 | 1.49349 | 0.00438434 | 34.417
4 x CV | +4.081 | +4.742 | 34.8 | 6409.8 | 6409.85 | 1.49349 | 0.00438434 | 34.417
CV | -0.320 | +4.076 | 32.1 | 5914.1 | 5914.09 | 1.37798 | 0.00404524 | 31.7551
CV | -0.319 | +4.675 | 34.5 | 6369 | 6368.98 | 1.48397 | 0.00435638 | 34.1976

# IfcBeam: ONDATHERM_T_80 (50)
In: Undefined
Description: ONDATHERM_T_80; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +3.682; Niveau haut: +5.039; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 2; Classe: 3; Matériau: S235JR; Profil: ONDATHERM_T_80; Nom: COUVERTURE
Tekla Quantités - Poids: 5598 kg; Volume: 0.6 m3; Surface supérieure totale: 0 m2; Surface par tonne: 3.8 m2; Surface nette: 21.4 m2; Hauteur: 119 mm; Largeur: 1077.6 mm; Longueur: 8352.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: A0(?)
BaseQuantities - Length: 8352.41 mm; OuterSurfaceArea: 21.3648 m2; NetVolume: 0.71312 m3; NetWeight: 5597.99 kg

# IfcColumn: IPE220 (8)
In: Undefined
Description: IPE220; Material: STEEL/S275JR
Pset_ColumnCommon - LoadBearing: no; Reference: 0(?)
Tekla Commun - Niveau bas: -0.285; Repère de pièce: 0(?); Repère d'assemblage: P0(?); Phase: 1; Classe: 7; Matériau: S275JR; Profil: IPE220; Nom: POTEAU
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 32.3 m2; Hauteur: 220 mm; Largeur: 110 mm
Name | Niveau haut | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x POTEAU | +3.963 | 111.4 | 3.7 | 4248.3 | 4248.33 | 3.60258 | 0.0136252 | 106.958
2 x POTEAU | +4.555 | 126.9 | 4.2 | 4840.1 | 4840.08 | 4.10439 | 0.0155533 | 122.093
2 x POTEAU | +3.363 | 95.7 | 3.2 | 3648.3 | 3648.33 | 3.09378 | 0.0116972 | 91.8228

# IfcColumn: IPE270 (2)
In: Undefined
Description: IPE270; Material: STEEL/S235JR
Tekla Commun - Niveau bas: -0.200; Niveau haut: +3.508; Repère de pièce: 0(?); Repère d'assemblage: P0(?); Phase: 1; Classe: 8; Matériau: S235JR; Profil: IPE270; Nom: CONTRE POTEAU
Tekla Quantités - Poids: 133.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 28.9 m2; Surface nette: 4 m2; Hauteur: 270 mm; Largeur: 135 mm; Longueur: 3707.5 mm
Pset_ColumnCommon - LoadBearing: no; Reference: 0(?)
BaseQuantities - Length: 3707.52 mm; OuterSurfaceArea: 3.85953 m2; NetVolume: 0.0163181 m3; NetWeight: 128.097 kg

# IfcColumn: IPE360 (10)
In: Undefined
Description: IPE360; Material: STEEL/S275JR
Pset_ColumnCommon - LoadBearing: no; Reference: 0(?)
Tekla Commun - Niveau bas: -0.285; Niveau haut: +3.574; Repère de pièce: 0(?); Repère d'assemblage: P0(?); Phase: 1; Classe: 7; Matériau: S275JR; Profil: IPE360; Nom: POTEAU
Tekla Quantités - Poids: 220.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 23.7 m2; Surface nette: 5.3 m2; Hauteur: 360 mm; Largeur: 170 mm; Longueur: 3859.2 mm
BaseQuantities - Length: 3859.2 mm; OuterSurfaceArea: 5.2215 m2; NetVolume: 0.0268055 m3; NetWeight: 210.423 kg

# IfcElementAssembly (175)
In: Undefined
Name | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
PORTE | 824.3 | +0.000 | +2.100 | 1/B-C | G0(?) | 50
PORTE | 824.3 | +0.000 | +2.100 | 6/D-E | G0(?) | 50
PORTE | 824.3 | +0.000 | +2.100 | 1/D-E | G0(?) | 50
PORTE | 4710 | +0.000 | +3.000 | 5-6/A | G0(?) | 50
PORTE | 4710 | +0.000 | +3.000 | 4-5/A | G0(?) | 50
PORTE | 4710 | +0.000 | +3.000 | 3-4/A | G0(?) | 50
PORTE | 4710 | +0.000 | +3.000 | 2-3/A | G0(?) | 50
PORTE | 4710 | +0.000 | +3.000 | 1-2/A | G0(?) | 50
BARDAGE | 23874.7 | +0.000 | +3.677 | 1-6/A | G0(?) | 100
BARDAGE | 54225.2 | +0.000 | +4.919 | 6/A-E | G0(?) | 100
BARDAGE | 52576.7 | +0.000 | +4.919 | 1/A-E | G0(?) | 100
BARDAGE | 70974.7 | +0.000 | +3.677 | 1-6/E | G0(?) | 100
5 x COUVERTURE | 5598 | +3.682 | +5.039 | 5-6/A-C | A0(?) | 1077.62
5 x COUVERTURE | 5598 | +3.682 | +5.039 | 5-6/C-E | A0(?) | 1077.62
5 x COUVERTURE | 5598 | +3.682 | +5.039 | 4-5/A-C | A0(?) | 1077.62
5 x COUVERTURE | 5598 | +3.682 | +5.039 | 4-5/C-E | A0(?) | 1077.62
5 x COUVERTURE | 5598 | +3.682 | +5.039 | 3-4/A-C | A0(?) | 1077.62
5 x COUVERTURE | 5598 | +3.682 | +5.039 | 3-4/C-E | A0(?) | 1077.62
5 x COUVERTURE | 5598 | +3.682 | +5.039 | 2-3/A-C | A0(?) | 1077.62
5 x COUVERTURE | 5598 | +3.682 | +5.039 | 2-3/C-E | A0(?) | 1077.62
5 x COUVERTURE | 5598 | +3.682 | +5.039 | 1-2/A-C | A0(?) | 1077.62
5 x COUVERTURE | 5598 | +3.682 | +5.039 | 1-2/C-E | A0(?) | 1077.62
CONTRE POTEAU | 139 | -0.200 | +3.520 | 4/A | P0(?) | 135
TRAVERSE | 225.9 | +2.953 | +3.525 | 3-4/A | A0(?) | 135
CONTRE POTEAU | 139 | -0.200 | +3.520 | 3/A | P0(?) | 135
2 x CV | 34.2 | -0.324 | +3.572 | 3-4/E | A0(?) | 60
2 x CV | 34.8 | +3.492 | +4.147 | 3-4/A-B | A0(?) | 60
2 x CV | 34.8 | +4.081 | +4.742 | 3-4/B-C | A0(?) | 60
2 x CV | 34.8 | +3.492 | +4.147 | 3-4/D-E | A0(?) | 60
2 x CV | 34.8 | +4.081 | +4.742 | 3-4/C-D | A0(?) | 60
CV | 32.1 | -0.320 | +4.076 | 6/C-D | A0(?) | 60
CV | 34.5 | -0.319 | +4.675 | 6/C-D | A0(?) | 60
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 1/D | P0(?) | 128
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 1/B | P0(?) | 128
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 1/C | P0(?) | 128
POTEAU | 117.5 | -0.300 | +3.963 | 1/D | P0(?) | 200
POTEAU | 117.5 | -0.300 | +3.963 | 1/B | P0(?) | 200
POTEAU | 133 | -0.300 | +4.555 | 1/C | P0(?) | 200
PANNE | 78.9 | +3.840 | +4.010 | 1-2/A-B | A0(?) | 82
PANNE | 78.9 | +4.138 | +4.308 | 1-2/B | A0(?) | 82
PANNE | 78.9 | +4.435 | +4.605 | 1-2/B-C | A0(?) | 82
PANNE | 78.9 | +3.543 | +3.713 | 1-2/A | A0(?) | 82
2 x PANNE | 78.9 | +4.733 | +4.903 | 1-2/C | A0(?) | 82
PANNE | 78.9 | +3.840 | +4.010 | 1-2/D-E | A0(?) | 82
PANNE | 78.9 | +4.138 | +4.308 | 1-2/D | A0(?) | 82
PANNE | 78.9 | +4.435 | +4.605 | 1-2/C-D | A0(?) | 82
PANNE | 78.9 | +3.543 | +3.713 | 1-2/E | A0(?) | 82
TRAVERSE | 528.2 | +2.899 | +4.767 | 1/A-C | A0(?) | 180
POTEAU | 243.7 | -0.300 | +3.583 | 1/A | P0(?) | 300
TRAVERSE | 528.2 | +2.899 | +4.767 | 1/C-E | A0(?) | 180
POTEAU | 243.7 | -0.300 | +3.583 | 1/E | P0(?) | 300
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 1/A | P0(?) | 128
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 1/E | P0(?) | 128
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 6/E | P0(?) | 128
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 6/D | P0(?) | 128
POTEAU | 101.8 | -0.300 | +3.363 | 6/E | P0(?) | 200
POTEAU | 117.5 | -0.300 | +3.963 | 6/D | P0(?) | 200
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 6/A | P0(?) | 128
POTEAU | 101.8 | -0.300 | +3.363 | 6/A | P0(?) | 200
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 6/B | P0(?) | 128
POTEAU | 117.5 | -0.300 | +3.963 | 6/B | P0(?) | 200
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 6/C | P0(?) | 128
POTEAU | 133 | -0.300 | +4.555 | 6/C | P0(?) | 200
RAMASSE | 183.2 | +3.345 | +4.757 | 6/A-C | A0(?) | 100
RAMASSE | 183.2 | +3.345 | +4.757 | 6/C-E | A0(?) | 100
TRAVERSE | 528.2 | +2.899 | +4.767 | 5/A-C | A0(?) | 180
POTEAU | 243.7 | -0.300 | +3.583 | 5/A | P0(?) | 300
TRAVERSE | 528.2 | +2.899 | +4.767 | 5/C-E | A0(?) | 180
POTEAU | 243.7 | -0.300 | +3.583 | 5/E | P0(?) | 300
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 5/A | P0(?) | 128
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 5/E | P0(?) | 128
PANNE | 78.9 | +3.840 | +4.010 | 5-6/A-B | A0(?) | 82
PANNE | 78.9 | +4.138 | +4.308 | 5-6/B | A0(?) | 82
PANNE | 78.9 | +4.435 | +4.605 | 5-6/B-C | A0(?) | 82
PANNE | 78.9 | +3.543 | +3.713 | 5-6/A | A0(?) | 82
2 x PANNE | 78.9 | +4.733 | +4.903 | 5-6/C | A0(?) | 82
PANNE | 78.9 | +3.840 | +4.010 | 5-6/D-E | A0(?) | 82
PANNE | 78.9 | +4.138 | +4.308 | 5-6/D | A0(?) | 82
PANNE | 78.9 | +4.435 | +4.605 | 5-6/C-D | A0(?) | 82
PANNE | 78.9 | +3.543 | +3.713 | 5-6/E | A0(?) | 82
TRAVERSE | 528.2 | +2.899 | +4.767 | 4/A-C | A0(?) | 180
POTEAU | 243.7 | -0.300 | +3.583 | 4/A | P0(?) | 300
TRAVERSE | 528.2 | +2.899 | +4.767 | 4/C-E | A0(?) | 180
POTEAU | 243.7 | -0.300 | +3.583 | 4/E | P0(?) | 300
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 4/A | P0(?) | 128
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 4/E | P0(?) | 128
PANNE | 78.9 | +3.840 | +4.010 | 4-5/A-B | A0(?) | 82
PANNE | 78.9 | +4.138 | +4.308 | 4-5/B | A0(?) | 82
PANNE | 78.9 | +4.435 | +4.605 | 4-5/B-C | A0(?) | 82
PANNE | 78.9 | +3.543 | +3.713 | 4-5/A | A0(?) | 82
2 x PANNE | 78.9 | +4.733 | +4.903 | 4-5/C | A0(?) | 82
PANNE | 78.9 | +3.840 | +4.010 | 4-5/D-E | A0(?) | 82
PANNE | 78.9 | +4.138 | +4.308 | 4-5/D | A0(?) | 82
PANNE | 78.9 | +4.435 | +4.605 | 4-5/C-D | A0(?) | 82
PANNE | 78.9 | +3.543 | +3.713 | 4-5/E | A0(?) | 82
TRAVERSE | 528.2 | +2.899 | +4.767 | 3/A-C | A0(?) | 180
POTEAU | 243.7 | -0.300 | +3.583 | 3/A | P0(?) | 300
TRAVERSE | 528.2 | +2.899 | +4.767 | 3/C-E | A0(?) | 180
POTEAU | 243.7 | -0.300 | +3.583 | 3/E | P0(?) | 300
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 3/A | P0(?) | 128
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 3/E | P0(?) | 128
PANNE | 78.9 | +3.840 | +4.010 | 3-4/A-B | A0(?) | 82
PANNE | 78.9 | +4.138 | +4.308 | 3-4/B | A0(?) | 82
PANNE | 78.9 | +4.435 | +4.605 | 3-4/B-C | A0(?) | 82
PANNE | 78.9 | +3.543 | +3.713 | 3-4/A | A0(?) | 82
2 x PANNE | 78.9 | +4.733 | +4.903 | 3-4/C | A0(?) | 82
PANNE | 78.9 | +3.840 | +4.010 | 3-4/D-E | A0(?) | 82
PANNE | 78.9 | +4.138 | +4.308 | 3-4/D | A0(?) | 82
PANNE | 78.9 | +4.435 | +4.605 | 3-4/C-D | A0(?) | 82
PANNE | 78.9 | +3.543 | +3.713 | 3-4/E | A0(?) | 82
TRAVERSE | 528.2 | +2.899 | +4.767 | 2/A-C | A0(?) | 180
TRAVERSE | 528.2 | +2.899 | +4.767 | 2/C-E | A0(?) | 180
POTEAU | 243.7 | -0.300 | +3.583 | 2/A | P0(?) | 300
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 2/A | P0(?) | 128
PANNE | 78.9 | +3.840 | +4.010 | 2-3/A-B | A0(?) | 82
PANNE | 78.9 | +4.138 | +4.308 | 2-3/B | A0(?) | 82
PANNE | 78.9 | +4.435 | +4.605 | 2-3/B-C | A0(?) | 82
PANNE | 78.9 | +3.543 | +3.713 | 2-3/A | A0(?) | 82
2 x PANNE | 78.9 | +4.733 | +4.903 | 2-3/C | A0(?) | 82
PANNE | 78.9 | +3.840 | +4.010 | 2-3/D-E | A0(?) | 82
PANNE | 78.9 | +4.138 | +4.308 | 2-3/D | A0(?) | 82
PANNE | 78.9 | +4.435 | +4.605 | 2-3/C-D | A0(?) | 82
PANNE | 78.9 | +3.543 | +3.713 | 2-3/E | A0(?) | 82
POTEAU | 243.7 | -0.300 | +3.583 | 2/E | P0(?) | 300
PRESCELLEMENT | 6.9 | -0.428 | -0.300 | 2/E | P0(?) | 128

# IfcMechanicalFastener: Bolt assembly (37)
In: Undefined
Tekla Boulons - Trou oblong Y: 0 mm; Trou oblong X: 0 mm; Lieu Boulonnage: Montage
Name | NominalDiameter (mm) = Diamètre rondelle (mm) = Diamètre (mm) | NominalLength (mm) = Longueur (mm) | Material = Standard | Quantité de rondelle | Type rondelle | Nom rondelle | Quantité d'écrou | Type écrou | Nom écrou | Diamètre du trou (mm) | Quantité | Nom
4 x Bolt assembly | 16 | 50 | HR8.8 | 12 | PLA-HR8.8 | RONDELLE-M16-PLA-HR8.8 | 6 | E-HR8.8 | ECROU-M16-E-HR8.8 | 18 | 6 | M16*50
8 x Bolt assembly | 20 | 23 | 6.8 | 0 | PLA-6.8 | RONDELLE-M20-PLA-6.8 | 0 | E-6.8 | ECROU-M20-E-6.8 | 20 | 2 | M20*40
10 x Bolt assembly | 16 | 60 | HR8.8 | 24 | PLA-HR8.8 | RONDELLE-M16-PLA-HR8.8 | 12 | E-HR8.8 | ECROU-M16-E-HR8.8 | 18 | 12 | M16*60
5 x Bolt assembly | 16 | 55 | 6.8 | 6 | PLA-6.8 | RONDELLE-M16-PLA-6.8 | 6 | E-6.8 | ECROU-M16-E-6.8 | 18 | 6 | M16*55
10 x Bolt assembly | 30 | 23 | 6.8 | 0 | PLA-6.8 | RONDELLE-M30-PLA-6.8 | 0 | E-6.8 | ECROU-M30-E-6.8 | 30 | 2 | M30*90

# IfcMember: IPE270 (2)
In: Undefined
Description: IPE270; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.963; Niveau haut: +3.250; Repère de pièce: 0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 1; Matériau: S235JR; Profil: IPE270; Nom: JARRET
Tekla Quantités - Poids: 25.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 28.9 m2; Surface nette: 0.3 m2; Hauteur: 251 mm; Largeur: 135 mm; Longueur: 718.9 mm
Pset_MemberCommon - LoadBearing: no; Reference: 0(?)
BaseQuantities - Length: 718.949 mm; OuterSurfaceArea: 0.748426 m2; GrossSurfaceArea: 0.748426 m2; CrossSectionArea: 0.00459 m2; NetVolume: 0.00251119 m3; GrossVolume: 0.00329998 m3; NetWeight: 19.7128 kg; GrossWeight: 25.9048 kg

# IfcPlate: 100*3677 (2)
In: Undefined
Description: 100*3677; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: G0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.677; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 2; Classe: 3; Matériau: S235JR; Profil: 100*3677; Nom: BARDAGE
Tekla Quantités - Surface supérieure totale: 0 m2; Hauteur: 3677 mm; Largeur: 100 mm; Longueur: 25220.2 mm
BaseQuantities - Width: 3677.01 mm; GrossArea: 92.7351 m2; CrossSectionArea: 0.01 m2; GrossVolume: 9.04136 m3
Name | Poids (kg) | Volume (m3) | Surface par tonne (m2) | Surface nette (m2) | NetArea (m2) | NetVolume (m3)
BARDAGE | 23874.7 | 3 | 2.9 | 69.6 | 69.5839 | 3.04136
BARDAGE | 70974.7 | 9 | 2.6 | 186.6 | 186.584 | 9.04136

# IfcPlate: 100*4919 (2)
In: Undefined
Description: 100*4919; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: G0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +4.919; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 2; Classe: 3; Matériau: S235JR; Profil: 100*4919; Nom: BARDAGE
Tekla Quantités - Surface supérieure totale: 0 m2; Surface par tonne: 2.6 m2; Hauteur: 4919.1 mm; Largeur: 100 mm; Longueur: 16560 mm
BaseQuantities - Width: 4919.11 mm; GrossArea: 81.4604 m2; CrossSectionArea: 0.01 m2; GrossVolume: 7.11766 m3
Name | Poids (kg) | Volume (m3) | Surface nette (m2) | NetArea (m2) | NetVolume (m3)
BARDAGE | 54225.2 | 6.9 | 142.6 | 142.639 | 6.90766
BARDAGE | 52576.7 | 6.7 | 138.9 | 138.859 | 6.69766

# IfcPlate: 50*1000 (3)
In: Undefined
Description: 50*1000; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.000; Niveau haut: +2.100; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 2; Classe: 1; Matériau: S235JR; Profil: 50*1000; Nom: PORTE
Tekla Quantités - Poids: 824.3 kg; Volume: 0.1 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 5.5 m2; Surface nette: 4.5 m2; Hauteur: 1000 mm; Largeur: 50 mm; Longueur: 2100 mm
Pset_PlateCommon - Support de charge: no; Réference: G0(?)
BaseQuantities - Width: 1000 mm; NetArea: 4.51 m2; GrossArea: 2.1 m2; CrossSectionArea: 0.0025 m2; NetVolume: 0.105 m3; GrossVolume: 0.105 m3

# IfcPlate: 50*3000 (5)
In: Undefined
Description: 50*3000; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: G0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +3.000; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Phase: 2; Classe: 1; Matériau: S235JR; Profil: 50*3000; Nom: PORTE
Tekla Quantités - Poids: 4710 kg; Volume: 0.6 m3; Surface supérieure totale: 0.2 m2; Surface par tonne: 5.2 m2; Surface nette: 24.7 m2; Hauteur: 3000 mm; Largeur: 50 mm; Longueur: 4000 mm
BaseQuantities - Width: 3000 mm; NetArea: 24.7 m2; GrossArea: 12 m2; CrossSectionArea: 0.0025 m2; NetVolume: 0.6 m3; GrossVolume: 0.6 m3

# IfcPlate: PL10*170 (10)
In: Undefined
Description: PL10*170; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +3.521; Niveau haut: +3.583; Repère de pièce: F0(?); Repère d'assemblage: P0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL10*170; Nom: COIFFE
Tekla Quantités - Poids: 4.7 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 27.7 m2; Surface nette: 0.1 m2; Hauteur: 170 mm; Largeur: 10 mm; Longueur: 351.9 mm
Pset_PlateCommon - Support de charge: no; Réference: F0(?)
BaseQuantities - Width: 170 mm; NetArea: 0.130082 m2; GrossArea: 0.130082 m2; CrossSectionArea: 0.0017 m2; NetVolume: 0.000598218 m3; GrossVolume: 0.000598218 m3

# IfcPlate: PL10*60 (4)
In: Undefined
Description: PL10*60; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +2.956; Niveau haut: +2.966; Repère de pièce: 0(?); Repère d'assemblage: P0(?); Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL10*60; Nom: PLAT
Tekla Quantités - Poids: 1.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 30.7 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 10 mm; Longueur: 249.6 mm
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
BaseQuantities - Width: 60 mm; NetArea: 0.0355183 m2; GrossArea: 0.014976 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.00014751 m3; GrossVolume: 0.00014751 m3

# IfcPlate: PL10*81 (40)
In: Undefined
Description: PL10*81; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
Tekla Commun - Niveau bas: -0.285; Niveau haut: -0.097; Repère de pièce: 0(?); Repère d'assemblage: P0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL10*81; Nom: RAIDISSEUR
Tekla Quantités - Poids: 1.2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 30 m2; Surface nette: 0 m2; Hauteur: 81 mm; Largeur: 10 mm; Longueur: 196.8 mm
BaseQuantities - Width: 81 mm; NetArea: 0.0346396 m2; GrossArea: 0.0159385 m2; CrossSectionArea: 0.0001 m2; NetVolume: 0.000146885 m3; GrossVolume: 0.000146885 m3

# IfcPlate: PL12*125 (2)
In: Undefined
Description: PL12*125; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
Tekla Commun - Niveau bas: +3.508; Niveau haut: +3.520; Repère de pièce: 0(?); Repère d'assemblage: P0(?); Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL12*125; Nom: PLAT
Tekla Quantités - Poids: 3.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 24.2 m2; Surface nette: 0.1 m2; Hauteur: 125 mm; Largeur: 12 mm; Longueur: 260 mm
BaseQuantities - Width: 125 mm; NetArea: 0.07424 m2; GrossArea: 0.07424 m2; CrossSectionArea: 0.0015 m2; NetVolume: 0.00039 m3; GrossVolume: 0.00039 m3

# IfcPlate: PL12*135 (2)
In: Undefined
Description: PL12*135; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
Tekla Commun - Niveau bas: +2.953; Niveau haut: +3.525; Repère de pièce: 0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 1; Matériau: S235JR; Profil: PL12*135; Nom: PLAT
Tekla Quantités - Poids: 7.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 23.6 m2; Surface nette: 0.2 m2; Hauteur: 135 mm; Largeur: 12 mm; Longueur: 571.5 mm
BaseQuantities - Width: 135 mm; NetArea: 0.171248 m2; GrossArea: 0.171248 m2; CrossSectionArea: 0.00162 m2; NetVolume: 0.00092576 m3; GrossVolume: 0.00092576 m3

# IfcPlate: PL12*180 (10)
In: Undefined
Description: PL12*180; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
Tekla Commun - Niveau bas: +4.240; Niveau haut: +4.252; Repère de pièce: 0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL12*180; Nom: AILE_JARRET
Tekla Quantités - Poids: 19.1 kg; Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface par tonne: 22.9 m2; Surface nette: 0.3 m2; Hauteur: 180 mm; Largeur: 12 mm; Longueur: 1126 mm
BaseQuantities - Width: 180 mm; NetArea: 0.436714 m2; GrossArea: 0.436714 m2; CrossSectionArea: 0.00216 m2; NetVolume: 0.00243222 m3; GrossVolume: 0.00243222 m3

# IfcPlate: PL12*80 (20)
In: Undefined
Description: PL12*80; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: F0(?)
Tekla Commun - Niveau bas: +2.910; Niveau haut: +2.922; Repère de pièce: F0(?); Repère d'assemblage: P0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL12*80; Nom: RAIDISSEUR
Tekla Quantités - Poids: 2.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 25.1 m2; Surface nette: 0.1 m2; Hauteur: 80 mm; Largeur: 12 mm; Longueur: 334 mm
BaseQuantities - Width: 80 mm; NetArea: 0.0622948 m2; GrossArea: 0.063376 m2; CrossSectionArea: 0.00096 m2; NetVolume: 0.00031584 m3; GrossVolume: 0.00032064 m3

# IfcPlate: PL15*160 (10)
In: Undefined
Description: PL15*160; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: F0(?)
Tekla Commun - Niveau bas: +2.899; Niveau haut: +3.579; Repère de pièce: F0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL15*160; Nom: PLATINE
Tekla Quantités - Poids: 12.8 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 19 m2; Surface nette: 0.2 m2; Hauteur: 160 mm; Largeur: 15 mm; Longueur: 680 mm
BaseQuantities - Width: 160 mm; NetArea: 0.2428 m2; GrossArea: 0.2428 m2; CrossSectionArea: 0.0024 m2; NetVolume: 0.001632 m3; GrossVolume: 0.001632 m3

# IfcPlate: PL15*180 (10)
In: Undefined
Description: PL15*180; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
Tekla Commun - Niveau bas: +4.227; Niveau haut: +4.767; Repère de pièce: 0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL15*180; Nom: PLAT
Tekla Quantités - Poids: 11.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 19 m2; Surface nette: 0.2 m2; Hauteur: 180 mm; Largeur: 15 mm; Longueur: 540 mm
BaseQuantities - Width: 180 mm; NetArea: 0.216 m2; GrossArea: 0.216 m2; CrossSectionArea: 0.0027 m2; NetVolume: 0.001458 m3; GrossVolume: 0.001458 m3

# IfcPlate: PL15*200 (8)
In: Undefined
Description: PL15*200; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
Tekla Commun - Niveau bas: -0.300; Niveau haut: -0.285; Repère de pièce: 0(?); Repère d'assemblage: P0(?); Finition: RAIDISSEUR; Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL15*200; Nom: PLAT
Tekla Quantités - Poids: 6.1 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 19.2 m2; Surface nette: 0.1 m2; Hauteur: 200 mm; Largeur: 15 mm; Longueur: 260 mm
BaseQuantities - Width: 200 mm; NetArea: 0.1178 m2; GrossArea: 0.1178 m2; CrossSectionArea: 0.003 m2; NetVolume: 0.00078 m3; GrossVolume: 0.00078 m3

# IfcPlate: PL15*300 (10)
In: Undefined
Description: PL15*300; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
Tekla Commun - Niveau bas: -0.300; Niveau haut: -0.285; Repère de pièce: 0(?); Repère d'assemblage: P0(?); Finition: RAIDISSEUR; Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL15*300; Nom: PLAT
Tekla Quantités - Poids: 9.2 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 18.8 m2; Surface nette: 0.2 m2; Hauteur: 300 mm; Largeur: 15 mm; Longueur: 260 mm
BaseQuantities - Width: 300 mm; NetArea: 0.1728 m2; GrossArea: 0.1728 m2; CrossSectionArea: 0.0045 m2; NetVolume: 0.00117 m3; GrossVolume: 0.00117 m3

# IfcPlate: PL8*170 (10)
In: Undefined
Description: PL8*170; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
Tekla Commun - Niveau bas: +4.252; Niveau haut: +4.421; Repère de pièce: 0(?); Repère d'assemblage: A0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL8*170; Nom: AME_JARRET
Tekla Quantités - Poids: 6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 35.1 m2; Surface nette: 0.2 m2; Hauteur: 168.9 mm; Largeur: 8 mm; Longueur: 1126 mm
BaseQuantities - Width: 168.904 mm; NetArea: 0.209659 m2; GrossArea: 0.403586 m2; CrossSectionArea: 0.00136 m2; NetVolume: 0.000760762 m3; GrossVolume: 0.0015314 m3

# IfcPlate: PL8*300 (8)
In: Undefined
Description: PL8*300; Material: STEEL/S235JR
Pset_PlateCommon - Support de charge: no; Réference: 0(?)
Tekla Commun - Niveau bas: -0.308; Niveau haut: -0.300; Repère de pièce: 0(?); Repère d'assemblage: P0(?); Phase: 1; Classe: 99; Matériau: S235JR; Profil: PL8*300; Nom: PRESCELLEMENT
Tekla Quantités - Poids: 5.7 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 33.5 m2; Surface nette: 0.2 m2; Hauteur: 300 mm; Largeur: 8 mm; Longueur: 300 mm
BaseQuantities - Width: 300 mm; NetArea: 0.1896 m2; GrossArea: 0.1896 m2; CrossSectionArea: 0.0024 m2; NetVolume: 0.00072 m3; GrossVolume: 0.00072 m3
